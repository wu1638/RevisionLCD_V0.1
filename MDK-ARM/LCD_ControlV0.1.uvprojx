# Keil uVision project LCD_ControlV0.1.uvprojx, settings and files
target LCD_ControlV0.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G031F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: LCD_ControlV1.1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\Application\Manager;..\Peripheral\GPIO;..\Peripheral\USART;..\Peripheral\Timer;..\Peripheral\LCD;..\Peripheral\CRC16;..\Peripheral\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_iwdg.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Application
    ../Application/Manager/: Manager.c Manager.h Manager_GPIO.c Manager_Usart.c Manager_Timer.c Mangager_LCD.c Manager_Sharing.c Variable_Define.h
  group Peripheral
    ../Peripheral/GPIO/: SuperGpio.c SuperGpio.h
    ../Peripheral/USART/: SuperUsart.c SuperUsart.h
    ../Peripheral/Timer/: SuperTimer.c SuperTimer.h
    ../Peripheral/LCD/: board_ht1621.c board_ht1621.h
    ../Peripheral/IWDG/: bsp_IWDG.c bsp_IWDG.h
    ../Peripheral/CRC16/: crc.c crc.h
software components: CMSIS:CORE 4.3.0
